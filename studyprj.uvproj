# Keil uVision project studyprj.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F105VC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: studyprj
  AfterMake: fromelf.exe OBJ\studyprj.axf --bin --output sim.bin
  c flags: Optim=1 OneElfS=1
  c define: USE_STDPERIPH_DRIVER,STM32F10X_CL
  c include: .\CORE;.\USER;.\FWLIB\inc;.\uCOS-II\Source;.\uCOS-II\Port;.\BSP
  library: MicroLIB
  memory RVCT4: ROM 0x800a000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./USER/: ecu_task.c pc_task.c main.c
  group BSP
    ./BSP/: bsp.c
  group CORE
    ./CORE/: core_cm3.c system_stm32f10x.c stm32f10x_it.c startup_stm32f10x_cl.s
  group FWLIB
    ./FWLIB/src/: stm32f10x_usart.c misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_wwdg.c
  group uCOS-II/Src
    ./uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group uCOS-II/Port
    ./uCOS-II/Port/: os_cpu_a.asm os_cpu_c.c os_dbg.c
